# Repository Lab-Compu-1/proyecto-base-2610946-barrios-coloradoduino

## KiCad design UccMicroDuino/2610946-Dante-Franco-Microduino/2610946-Dante-Franco-Microduino.kicad_pcb

Board: 2 copper layers, 45.0 x 45.0 mm, 14 parts (0 on the bottom side), 13 nets.

Parts:
C1: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: PMLL4148L; D_MiniMELF
D2, D3: 3.6V 1/2mW; D_SOD-123
D4: Led Green; ledSMD
D5: LED; ledSMD
J1: Pcb USB Type A; USB_A_UCC
J2: Header; PinHeader_1x10_P2.54mm_Vertical
R1: 1.5KΩ 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 68Ω 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 330Ω 5% 1/8W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ATtiny85-20SU; SOIC-8W_5.3x5.3mm_P1.27mm

Connections:
+5V: C1.1, D1.1 (K), D5.2 (A), J2.1, R1.1, U1.8 (VCC)
GND: C1.2, D2.2 (A), D3.2 (A), J1.4 (GND), J2.2, R4.2, R5.2, U1.4 (GND)
unnamed: D1.2 (A), J1.1 (VBUS)
unnamed: D2.1 (K), J1.2 (D-), R1.2, R2.2
unnamed: D3.1 (K), J1.3 (D+), R3.1
unnamed: D4.2 (A), J2.5, U1.6 (PB1)
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: J2.4, U1.5 (AREF/PB0)
unnamed: J2.6, U1.7 (PB2)
unnamed: J2.7, R2.1, U1.2 (XTAL1/PB3)
unnamed: J2.8, R3.2, U1.3 (XTAL2/PB4)
unnamed: J2.9, U1.1 (~RESET/PB5)

## Commit log

2026-04-06 Setting up GitHub Classroom Feedback
2026-04-06 GitHub Classroom Feedback
2026-04-13 Entrega de archivos Microduino
2026-05-18 Entrega Placa
2026-05-18 Entrega de Microduino limpia
2026-05-18 Renombrado de archivos internos
2026-05-18 2610946- Mi primer commit con git
